# Keil uVision project m7os.uvprojx, settings and files
target STM32F746G-DISCO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: m7os
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group APP
    ./: main.c console.c console.h board.c board.h Config.h
software components: RTOS:Config 10.2.1, RTOS:Core 10.2.1, RTOS:Heap 10.2.1, CMSIS:CORE 5.3.0, Device:STM32Cube Framework:Classic 1.2.7, Device:STM32Cube HAL:Common 1.2.7, Device:STM32Cube HAL:Cortex 1.2.7, Device:STM32Cube HAL:DMA 1.2.7, Device:STM32Cube HAL:GPIO 1.2.7, Device:STM32Cube HAL:PWR 1.2.7, Device:STM32Cube HAL:RCC 1.2.7, Device:STM32Cube HAL:UART 1.2.7, Device:Startup 1.2.4
